# IAR project lsm6ds3-pu.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\!LIB\STM32F40x_StdPeriph_Driver\inc; ..\!LIB\CMSIS\CM4\DeviceSupport\ST\STM32F40x; ..\!LIB\Device\ARM\ARMCM4\Include; ..\!LIB\lsm6ds3-st; ..\Core\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lsm6ds3-pu.bin
  ILINK.IlinkOutputFile: lsm6ds3-pu.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group !BASE/I2C_NONBLOCK
    ../Core/Source/: i2c_nb.c
    ../Core/Include/: i2c_nb.h
  group Driver/bmp280
    ../Core/Include/: bmp280_defs.h
  group Driver/CMSIS
    ../!LIB/CMSIS/CM4/DeviceSupport/ST/STM32F40x/startup/iar/: startup_stm32f40x.s
    ../!LIB/CMSIS/CM4/DeviceSupport/ST/STM32F40x/: system_stm32f40x.c
  group Driver/lsm6ds3
    ../!LIB/lsm6ds3-st/: lsm6ds3_reg.c lsm6ds3_reg.h
  group Driver/StdPeriph
    ../!LIB/STM32F40x_StdPeriph_Driver/src/: misc.c stm32f40x_adc.c stm32f40x_can.c stm32f40x_crc.c stm32f40x_cryp.c stm32f40x_cryp_aes.c stm32f40x_cryp_des.c stm32f40x_cryp_tdes.c stm32f40x_dac.c stm32f40x_dbgmcu.c stm32f40x_dcmi.c stm32f40x_dma.c stm32f40x_exti.c stm32f40x_flash.c stm32f40x_fsmc.c stm32f40x_gpio.c stm32f40x_hash.c stm32f40x_hash_md5.c stm32f40x_hash_sha1.c stm32f40x_i2c.c stm32f40x_iwdg.c stm32f40x_pwr.c stm32f40x_rcc.c stm32f40x_rng.c stm32f40x_rtc.c stm32f40x_sdio.c stm32f40x_spi.c stm32f40x_syscfg.c stm32f40x_tim.c stm32f40x_usart.c stm32f40x_wwdg.c
  group User/Inc
    ../Core/Include/: bmp280_i2c.h lsm6ds3_test.h main.h stm32f40x_conf.h stm32f4xx_it.h timer0.h
  group User/Src
    ../Core/Source/: bmp280_i2c.c lsm6ds3_test.c main.c stm32f4xx_it.c timer0.c
